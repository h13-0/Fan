# IAR project fan.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 50
  General.GenHeapSize: 50
  ICCSTM8.CCIncludePath2: D:\Projects\Fan\STM8\Libraries\STM8S_StdPeriph_Driver\inc; D:\Projects\Fan\STM8\Project\FAN
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Fan.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group app
    ./: main.c stm8s_it.c
  group std_lib
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
